Commit message: Change scale (upscale)

File: resources/objects/shoes/shoes.urdf (robot description, URDF)
Before this commit: robot shoes.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=nb574.obj scale=0.1 0.1 0.1; visual mesh filename=nb574.obj scale=0.1 0.1 0.1
